# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc;.\Config
  group Src
    ./: STARTUP.A51
    ./Src/: codetab.c Delay.c IIC.c Main.c OLED.c SPI.c
  group Inc
    ./Inc/: codetab.h Delay.h IIC.h OLED.h SPI.h intrins.h
  group Config
    ./Config/: Config.h reg52.h
